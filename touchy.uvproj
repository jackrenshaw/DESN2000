# Keil uVision project touchy.uvproj, settings and files
target QVGA Base Board (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: touchy
  c flags: Optim=1 wLevel=2
  asm misc: --diag_suppress 1608,6314
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --first=LPC2400.o(RESET) --bestdebug --arm_only
  group Startup
    ./src/: LPC2400.s startup.c
  group Source Code
    ./src/: touchy.s assignment.c bubbles.c delay.c gpio_simulate_speed.c main.c touch.c assignment_gpio.h bubbles.h const.h delay.h lpc24xx.h touch.h useful_functions.h delay.s
